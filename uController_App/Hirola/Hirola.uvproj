# Keil uVision project Hirola.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC831 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: Hirola +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./: main.c
  group Files
    ./: definitions.c definitions.h timers.c timers.h putchar.c putchar.h header.h header.c
